inherit systemd

SYSTEMD_SERVICE_${PN} = "connman.service"

SYSTEMD_AUTO_ENABLE = "disable"
